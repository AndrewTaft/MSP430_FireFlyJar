# Repository AndrewTaft/MSP430_FireFlyJar

File README.md:

MSP430_FireFlyJar
=================

MSP430 ValueLine FireFlyJar.  With Max44009 I2C LUX Sensor, and CapTouch Buttons

## KiCad design Kicad/FireFlyLid/FireFlyLid.kicad_pcb

Parts:
BAT1: BAT
C1: 100nF
C2, C3: 1uF
C4: 470pF
J1: HEADER_4
J2, J3: HEADER_1
LD1, LD2, LD3, LD4, LD5, LD6, LD7, LD8, LD9, LD10, LD11, LD12, LD13, LD14, LD15, LD16, LD17, LD18, LD19: LED
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16, R17, R18, R19: RESISTOR
R20: 47K
R30, R31, R32: 10K
SW1: SW_SPDT
U1: MSP430G2553IPW28
U2: MAXIM_MAX44009
VDET1: VDETECTOR_3PINS-SOT-223; dp_devices-SOT-223
VREG1: VREG_5PINS-SOT-23-5; dp_devices-SOT-23-5
X1: 32K

Connections:
/GND: BAT1.2, C1.2, C2.1, C3.2, C4.2, J1.2, R1.1, R2.1, R3.1, R4.1, R5.1, R6.1, R7.1, R8.1, R9.1, R10.1, R11.1, R12.1, R13.1, R14.1, R15.1, R16.1, R17.1, R18.1, R19.1, U1.28 (DVSS), U2.2 (GND), U2.3 (AD), VDET1.2 (VSS), VREG1.2 (GND), X1.3 (GND)
/P1.0: LD1.1 (A), U1.2 (P1.0/TA0CLK/ACLK/A0/CA0)
/P1.1: J2.1, U1.3 (P1.1/TA0.0/UCA0RXD/UCA0SOMI/A1/CA1)
/P1.2: LD2.1 (A), U1.4 (P1.2/TA0.1/UCA0TXD/UCA0SIMO/A2/CA2)
/P1.3: LD16.1 (A), U1.5 (P1.3/ADC10CLK/CAOUT/VREF-/VEREF-/A3/CA3)
/P1.4: LD3.1 (A), U1.6 (P1.4/SMCLK/UCB0STE/UCA0CLK/VREF+/VEREF+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)
/P1.5: LD4.1 (A), U1.7 (P1.5/TA0.0/UCB0CLK/UCA0STE/A5/CA5/TMS)
/P2.0: LD5.1 (A), U1.10 (P2.0/TA1.0)
/P2.1: LD6.1 (A), U1.11 (P2.1/TA1.1)
/P2.2: LD7.1 (A), U1.12 (P2.2/TA1.1)
/P2.3: J3.1, U1.16 (P2.3/TA1.0)
/P2.4: LD8.1 (A), U1.17 (P2.4/TA1.2)
/P2.5: LD17.1 (A), U1.18 (P2.5/TA1.2)
/P2.6: LD18.1 (A), U1.27 (XIN/P2.6/TA0.1), X1.2
/P2.7: LD19.1 (A), U1.26 (XOUT/P2.7), X1.1
/P3.0: LD9.1 (A), U1.9 (P3.0/TA0.2)
/P3.1: LD10.1 (A), U1.8 (P3.1/TA1.0)
/P3.2: LD11.1 (A), U1.13 (P3.2/TA1.1)
/P3.3: LD12.1 (A), U1.14 (P3.3/TA1.2)
/P3.4: LD13.1 (A), U1.15 (P3.4/TA0.0)
/P3.5: LD14.1 (A), U1.19 (P3.5/TA0.1)
/P3.6: LD15.1 (A), U1.20 (P3.6/TA0.2)
/P3.7: R32.2, U1.21 (P3.7/TA1CLK/CAOUT), U2.4 (INT)
/PROG_VCC: J1.1, SW1.3 (NO)
/RST: J1.4, R20.1, U1.24 (~RST~/NMI/SBWTDIO)
/SCL: R30.2, U1.22 (P1.6/TA0.1/UCB0SOMI/UCB0SCL/A6/CA6/TDI/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), U2.5 (SCL)
/SDA: R31.2, U1.23 (P1.7/CAOUT/UCB0SIMO/UCB0SDA/A7/CA7/TDO/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), U2.6 (SDA)
/TEST: J1.3, U1.25 (TEST/SBWTCK)
/VCC: C1.1, C2.2, C3.1, R20.2, R30.1, R31.1, R32.1, U1.1 (DVCC), U2.1 (VCC), VREG1.5 (OUT)
unnamed: LD16.2 (K), R16.2
unnamed: LD17.2 (K), R17.2
unnamed: LD18.2 (K), R18.2
unnamed: LD11.2 (K), R11.2
unnamed: LD12.2 (K), R12.2
unnamed: LD10.2 (K), R10.2
unnamed: LD9.2 (K), R9.2
unnamed: LD13.2 (K), R13.2
unnamed: LD14.2 (K), R14.2
unnamed: LD15.2 (K), R15.2
unnamed: C4.1, VREG1.4 (BYP)
unnamed: VDET1.1 (VOUT), VREG1.3 (EN)
unnamed: BAT1.1, SW1.1 (NC)
unnamed: LD19.2 (K), R19.2
unnamed: SW1.2 (COM), VDET1.3 (VIN), VREG1.1 (IN)
unnamed: LD1.2 (K), R1.2
unnamed: LD4.2 (K), R4.2
unnamed: LD6.2 (K), R6.2
unnamed: LD5.2 (K), R5.2
unnamed: LD3.2 (K), R3.2
unnamed: LD7.2 (K), R7.2
unnamed: LD8.2 (K), R8.2
unnamed: LD2.2 (K), R2.2

Notes on the sheet:
PROG HEAD
CAP TOUCH
LIGHT SENSOR
LED ARRAY
OPTIONAL LEDS
POWER MANAGEMENT
Change P3.7 for interrupt to use P1 or P2

Board: 2 copper layers, 81.3 x 81.3 mm, 56 parts (4 on the bottom side), 52 nets.

## Commit log

2013-11-11 First Checkin of a blank project
2013-11-11 First blank project checkin
2013-11-14 Resources figured out. Optimization on bytePivot taking from 2400 cycles to 500
2014-09-21 Kicad schema and board
    First layout with Battery. Board works. Battery does not last long
    enough.
2014-09-21 New layout with off board battery and local vreg to 3.0 V
2014-10-04 On hiatus, This is a checkin of work done up until 12/01/2013
2014-10-04 On Hiatus, This is a checkin of work done up to 12/1/2013
2014-10-04 Working version has 3 modes.
2014-10-04 Checking in everything
2014-10-04 Changed to 16mhz clock due to LDO and use of LIPO
2015-02-14 Checkin mid work
2015-02-16 mid work
